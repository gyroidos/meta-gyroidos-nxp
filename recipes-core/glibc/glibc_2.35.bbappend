# workarround until upstream layer meta-tq is fixed
SRC_URI:remove = "file://0002-sunrpc-Suppress-GCC-Os-warning-on-user2netname.patch"
