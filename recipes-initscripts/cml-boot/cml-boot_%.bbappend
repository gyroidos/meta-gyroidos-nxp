## Remove redirection of console output to enable automatic start of CML on NXP devices
SRC_URI:remove = "file://15-redirect-logtty.fragment"
