FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-rtnetlink-Allow-deleting-FDB-entries-in-user-namespa.patch"

