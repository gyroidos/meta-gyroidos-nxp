FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI:append:tqmlx2160a-mblx2160a = "\
	file://0001-daemon-c_idmapped-enable-idmapped-mount-support-for-.patch \
"

